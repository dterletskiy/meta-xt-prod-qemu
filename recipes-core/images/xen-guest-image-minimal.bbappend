IMAGE_INSTALL:append = " \
   packagegroup-epam-xen-guest \
"
