IMAGE_INSTALL:append = " \
   packagegroup-epam-xen \
   packagegroup-epam-test \
"
